# Keil uVision project Project_52230.uvprojx, settings and files
target HT32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HT32F52220_24SSOP Holtek
  pack: Holtek.HT32_DFP.1.0.32
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HT32 +hex
  AfterMake: fromelf --bin -o "!L.bin" "!L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F52230_SK, USE_HT32F52220_30, USE_MEM_HT32F52220
  c include: ..\;..\..\..\..\library\CMSIS\Include;..\..\..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\..\library\HT32F5xxxx_Driver\inc;..\..\..\..\library\HT32_USBD_Library\inc;..\..\..\..\utilities;..\app_btn;..\lcd;..\app_debug;..\SEGGER_RTT_V698b\RTT;..\sync_drv;..\app_flash;..\hdc2080;..\lpf
  asm define: USE_HT32_CHIP=1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --entry Reset_Handler
  group User
    ../: main.c ht32f5xxxx_01_it.c
  group Config
    ../: _ht32_project_source.h ht32_board_config.h ht32f5xxxx_conf.h
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
  group CMSIS
    ../: system_ht32f5xxxx_02.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Library
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_wdt.c
  group Retarget
    ../../../../library/HT32F5xxxx_Driver/src/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../../../utilities/: ht32_board.c
    ../../../../utilities/common/: i2c_eeprom.c spi_flash.c spi_lcd.c
  group Doc
    ../: readme.txt
  group app_btn
    ../app_btn/: app_btn.c app_btn.h
  group lcd
    ../lcd/: lcd.c lcd.h
  group app_debug
    ../app_debug/: app_debug.c app_debug.h
  group SeggerRTT
    ../SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group app_sync
    ../sync_drv/: app_sync.c app_sync.h clist.h sync_drv.c sync_drv.h
  group app_flash
    ../app_flash/: app_flash.c app_flash.h
  group hdc2080
    ../hdc2080/: hdc2080.c hdc2080.h
  group lpf
    ../lpf/: lpf.c lpf.h
